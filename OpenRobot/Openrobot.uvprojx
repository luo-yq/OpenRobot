# Keil uVision project Openrobot.uvprojx, settings and files
target openRobot (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F746ZGTx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.11.0
  cpu: IRAM(0x20010000,0x40000) IRAM2(0x20000000,0x10000) IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: Openrobot
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F746xx,USE_HAL_DRIVER
  c misc: --cpp11
  c include: ..\lib\STM32F7xx_HAL_Driver\Inc;..\lib\STM32F7xx_HAL_Driver\Inc\Legacy;.\inc;..\lib\drvice;..\lib\drvice\UART;..\lib\drvice\UART\avr;..\lib\STM32F7xx_HAL_Driver\Src;..\lib\opencr;..\lib\opencr\include;..\lib\libraries\IMU;..\lib\libraries\turtlebot3_ros_lib\ros;..\lib\libraries\turtlebot3_ros_lib;..\lib\libraries\turtlebot3_ros_lib\geometry_msgs;..\lib\libraries\turtlebot3_ros_lib\nav_msgs;..\lib\libraries\turtlebot3_ros_lib\roscpp;..\lib\libraries\turtlebot3_ros_lib\rosserial_arduino;..\lib\libraries\turtlebot3_ros_lib\rosserial_msgs;..\lib\libraries\turtlebot3_ros_lib\sensor_msgs;..\lib\libraries\turtlebot3_ros_lib\std_msgs;..\lib\libraries\turtlebot3_ros_lib\std_srvs;..\lib\libraries\turtlebot3_ros_lib\tf;..\lib\libraries\turtlebot3_ros_lib\tf2_msgs;..\lib\libraries\turtlebot3_ros_lib\turtlebot3_msgs;..\lib\arduino;..\lib\arduino\avr;..\lib\libraries\IMU_I2C;..\lib\USB\USB_APP;..\lib\USB\STM32_USB_OTG_Driver\inc;..\lib\USB\STM32_USB_Device_Library\Class\cdc\inc;..\lib\USB\STM32_USB_Device_Library\Core\inc;..\lib\usb_cdc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20010000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group main
    ./src/: main.cpp CPackage.cpp CMotor.cpp CKalman.cpp CSonar.cpp
    ./inc/: CMotor.h CPackage.h main.h CKalman.h CSonar.h
  group core
    ../lib/opencr/include/: core_cm7.h core_cmFunc.h core_cmInstr.h core_cmSimd.h
    ../lib/opencr/: system_stm32f7xx.c stm32f7xx_it.c
    ../lib/opencr/startup/: startup_stm32f746xx.s
  group drv
    ../lib/drvice/: delay.c sys.c drv_led.c drv_spi.c drv_pin.c drv_uart.c drv_micros.c drv_include.h delay.h drv_led.h drv_micros.h drv_pin.h drv_spi.h sys.h drv_uart.h drv_timer.c drv_motor.c wdg.c drv_exti.c drv_motor.h drv_exti.h wdg.h vcp.c drv_battery.c drv_battery.h
    ../lib/opencr/: bsp.c system_clock.c
  group lib_hal
    ../lib/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_cortex.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_usart.c stm32f7xx_hal_spi.c stm32f7xx_hal_pcd.c stm32f7xx_hal_pcd_ex.c stm32f7xx_hal_iwdg.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_ltdc_ex.c stm32f7xx_ll_sdmmc.c stm32f7xx_ll_fmc.c stm32f7xx_ll_usb.c stm32f7xx_hal_adc.c stm32f7xx_hal_adc_ex.c
  group lib_IMU
    ../lib/libraries/IMU/: Define.h imu_spi.cpp imu_spi.h SPI.cpp SPI.h MadgwickAHRS.cpp MadgwickAHRS.h MPU9250.cpp MPU9250.h MPU9250_REGS.h IMU.h IMU.cpp
  group lib_ros
    ../lib/libraries/turtlebot3_ros_lib/: duration.cpp time.cpp
  group arduino
    ../lib/drvice/UART/: itoa.c WMath.cpp UARTClass.cpp Stream.cpp RingBuffer.cpp RingBuffer.h WString.cpp Print.cpp USBSerial.cpp DataScope_DP.C
    ../lib/drvice/UART/avr/: dtostrf.c
  group IMU_I2C
    ../lib/libraries/IMU_I2C/: myiic.c mpu.c myiic.h mpu.h mpu9250_iic.c mpu9250_iic.h 24cxx.c 24cxx.h
  group USB
    ../lib/usb_cdc/: usbd_cdc.c usbd_cdc_interface.c usbd_conf.c usbd_core.c usbd_ctlreq.c usbd_desc.c usbd_ioreq.c
